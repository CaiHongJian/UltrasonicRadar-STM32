# Keil uVision project STM32F1Dog_HAL.uvprojx, settings and files
target STM32F1Dog_HAL (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: STM32F1Dog_HAL +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Drivers/Key;../Drivers/OLED;../Drivers/PWM;../Drivers/Servo;../Drivers/Robot;../Drivers/Expression;../Drivers/Ultrasonic;../Drivers/Delay;../Drivers/BreathLED;../Drivers/Buzzer;..\Drivers\RadarUI
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c tim.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/Delay
    ../Drivers/Delay/: delay.c delay.h
  group Drivers/Key
    ../Drivers/Key/: key.c key.h
  group Drivers/OLED
    ../Drivers/OLED/: oled.c oled_font.c oled.h oled_font.h
  group Drivers/Ultrasonic
    ../Drivers/Ultrasonic/: ultrasonic.c ultrasonic.h
  group BreathLED
    ../Drivers/BreathLED/: breath_led.c breath_led.h
  group Buzzer
    ../Drivers/Buzzer/: buzzer.c buzzer.h
  group PWM
    ../Drivers/PWM/: pwm.c pwm.h
  group Servo
    ../Drivers/Servo/: servo.c servo.h
  group RadarUI
    ../Drivers/RadarUI/: radar_ui.c radar_ui.h
software components: CMSIS:CORE 4.3.0
